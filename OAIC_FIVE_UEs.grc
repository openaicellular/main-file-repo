options:
  parameters:
    generate_options: qt_gui
    id: multi_ue
    output_language: python
    title: Multi UE Flowgraph
  states: {}

blocks:
- name: cell_gain0
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: min_gain
    step: '0.0001'
    stop: max_gain
    value: '0.050'
  states: {}
- name: cell_gain1
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: min_gain
    step: '0.0001'
    stop: max_gain
    value: '0.080'
  states: {}
- name: cell_gain2
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: min_gain
    step: '0.0001'
    stop: max_gain
    value: '0.05'
  states: {}
- name: cell_gain3
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: min_gain
    step: '0.0001'
    stop: max_gain
    value: '0.04'
  states: {}
- name: cell_gain4
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: min_gain
    step: '0.0001'
    stop: max_gain
    value: '0.06'
  states: {}
- name: max_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: min_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 23.04e6
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: cell_gain0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: cell_gain1
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: cell_gain1
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: cell_gain3
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: cell_gain4
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: cell_gain2
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: cell_gain4
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: cell_gain3
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: cell_gain0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: cell_gain2
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2009
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2008
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2006
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2400
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1_0_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2500
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2300
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2010
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2007
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2301
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2501
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0_1
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2401
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_1
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2000
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_throttle_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', zeromq_rep_sink_1_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', zeromq_rep_sink_1_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0_0, '0', zeromq_rep_sink_1_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_1, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_0_1_0, '0', blocks_add_xx_0, '4']
- [blocks_multiply_const_vxx_0_0_2, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_0_1, '0', zeromq_rep_sink_1, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', zeromq_rep_sink_1_1, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_0_0_0_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [blocks_throttle_0_0, '0', zeromq_rep_sink_0, '0']
- [zeromq_req_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [zeromq_req_source_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [zeromq_req_source_0_0_0, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [zeromq_req_source_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_1_0, '0']
- [zeromq_req_source_0_0_1, '0', blocks_multiply_const_vxx_0_0_2, '0']
- [zeromq_req_source_1, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
