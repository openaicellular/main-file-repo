options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: gain0
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0.001'
    step: '0.001'
    stop: '0.999'
    value: '0.05'
  states: {}
- name: gain1
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0.001'
    step: '0.001'
    stop: '0.999'
    value: '0.03'
  states: {}
- name: gain2
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0.001'
    step: '0.001'
    stop: '0.999'
    value: '0.08'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 23.04e6
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain1
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain1
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: gain1
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain1
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: gain2
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain2
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: gain2
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain2
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: gain0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_3
  id: blocks_multiply_const_vxx
  parameters:
    const: gain0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_3_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain0
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2001
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2101
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2053
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2153
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2154
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2054
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_2
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2052
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_2_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2152
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2003
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2103
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2104
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_1
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2004
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_1
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2002
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_1_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2102
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_3
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2000
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_3_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2100
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_add_xx_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_const_vxx_0_0_1, '0', zeromq_rep_sink_1, '0']
- [blocks_multiply_const_vxx_0_0_1_0, '0', zeromq_rep_sink_1_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_1_0, '0', blocks_add_xx_0_0, '2']
- [blocks_multiply_const_vxx_0_1_1, '0', zeromq_rep_sink_1_1, '0']
- [blocks_multiply_const_vxx_0_1_1_0, '0', zeromq_rep_sink_1_0_0, '0']
- [blocks_multiply_const_vxx_0_2, '0', blocks_add_xx_0_0, '0']
- [blocks_multiply_const_vxx_0_3, '0', zeromq_rep_sink_2, '0']
- [blocks_multiply_const_vxx_0_3_0, '0', zeromq_rep_sink_2_0, '0']
- [blocks_throttle_0, '0', zeromq_rep_sink_0, '0']
- [blocks_throttle_0_0, '0', zeromq_rep_sink_0_0, '0']
- [blocks_throttle_0_0_0, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [blocks_throttle_0_0_0, '0', blocks_multiply_const_vxx_0_1_1, '0']
- [blocks_throttle_0_0_0, '0', blocks_multiply_const_vxx_0_3, '0']
- [blocks_throttle_0_0_1, '0', blocks_multiply_const_vxx_0_0_1_0, '0']
- [blocks_throttle_0_0_1, '0', blocks_multiply_const_vxx_0_1_1_0, '0']
- [blocks_throttle_0_0_1, '0', blocks_multiply_const_vxx_0_3_0, '0']
- [zeromq_req_source_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [zeromq_req_source_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [zeromq_req_source_0_0_0, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [zeromq_req_source_0_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [zeromq_req_source_1, '0', blocks_multiply_const_vxx_0, '0']
- [zeromq_req_source_1_0, '0', blocks_multiply_const_vxx_0_2, '0']
- [zeromq_req_source_3, '0', blocks_throttle_0_0_0, '0']
- [zeromq_req_source_3_0, '0', blocks_throttle_0_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
